# IAR project my_assembly_ISR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PGE TexasInstruments TM4C123GH6PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_TM4C123_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: my_assembly_ISR.bin
  ILINK.IlinkOutputFile: my_assembly_ISR.out
  ILINK.IlinkIcfFile: my_assembly_ISR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ../drivers/: cfal96x64x16.c
    ./: Int1Handler_ASM.s my_assembly_ISR.c startup_ewarm.c
